# Keil uVision project gcc_example.uvprojx, settings and files
target example (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gcc_example +hex
  group startup
    ./gcc/: startup_ARMCM0.c system_ARMCM0.c
  group application
    ./: main.c platform.c stdout_USART.c pt_example.c pt_example.h cpt_example.c cpt_example.h
  group perf_counter
    ../: perf_counter.c perf_counter.h systick_wrapper_gcc.s perfc_port_default.c perfc_port_default.h
target gcc_lib (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: perf_counter_gcc (library)
  AfterMake: copy.bat
software components: CMSIS:CORE 6.1.1, Language Extension:Coroutine 1.0.0, Language Extension:protoThread 1.1.0, Utilities:perf_counter:Core 2.5.3-dev
